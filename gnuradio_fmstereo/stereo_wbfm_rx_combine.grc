<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>author</key><value>Yuan Wang (BG3MDO)</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>title</key><value>Stereo (Two Mode Demod) WBFM RX by BG3MDO</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>fm_freq</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>value</key><value>103e6</value></param>
<param><key>label</key><value>Frequency(Hz)</value></param>
<param><key>max</key><value>108e6</value></param>
<param><key>min</key><value>88e6</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sample_rate</value></param>
<param><key>value</key><value>1024000</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>variable_chooser_0</value></param>
<param><key>choices</key><value>[0, 1, 2]</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>Stereo Demodulation Mode</value></param>
<param><key>labels</key><value>['None', 'Mode 1(Sync Demod)', 'Mode 2(Sampling)']</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>type</key><value>radio_buttons</value></param>
</block>
<block>
<key>analog_fm_deemph</key>
<param><key>id</key><value>analog_fm_deemph_0</value></param>
<param><key>samp_rate</key><value>384e3</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>analog_fm_deemph</key>
<param><key>id</key><value>analog_fm_deemph_1</value></param>
<param><key>samp_rate</key><value>384e3</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>analog_fm_demod_cf</key>
<param><key>id</key><value>analog_fm_demod_cf_0</value></param>
<param><key>audio_decim</key><value>1</value></param>
<param><key>audio_pass</key><value>90000</value></param>
<param><key>audio_stop</key><value>94000</value></param>
<param><key>chan_rate</key><value>sample_rate</value></param>
<param><key>deviation</key><value>75000</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>tau</key><value>0</value></param>
</block>
<block>
<key>analog_pll_refout_cc</key>
<param><key>id</key><value>analog_pll_refout_cc_0</value></param>
<param><key>w</key><value>2e-4</value></param>
<param><key>max_freq</key><value>311.705e-3</value></param>
<param><key>min_freq</key><value>310.068e-3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>audio_device</value></param>
<param><key>label</key><value>Audio device</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>default</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_1</value></param>
<param><key>device_name</key><value>audio_device</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_fcc</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>high_cutoff_freq</key><value>20e3</value></param>
<param><key>low_cutoff_freq</key><value>18e3</value></param>
<param><key>samp_rate</key><value>384e3</value></param>
<param><key>width</key><value>1000</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0_0_0_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>2</value></param>
<param><key>high_cutoff_freq</key><value>41e3</value></param>
<param><key>low_cutoff_freq</key><value>35e3</value></param>
<param><key>samp_rate</key><value>384e3</value></param>
<param><key>width</key><value>1e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0_1</value></param>
<param><key>input_index</key><value>variable_chooser_0</value></param>
<param><key>num_inputs</key><value>3</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0_2</value></param>
<param><key>input_index</key><value>variable_chooser_0</value></param>
<param><key>num_inputs</key><value>3</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0_0</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0_0_0</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>4</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>10</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_2</value></param>
<param><key>const</key><value>-1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_peak_detector_xb</key>
<param><key>id</key><value>blocks_peak_detector_xb_0</value></param>
<param><key>alpha</key><value>0.001</value></param>
<param><key>type</key><value>float</value></param>
<param><key>look_ahead</key><value>10</value></param>
<param><key>threshold_factor_fall</key><value>0.40</value></param>
<param><key>threshold_factor_rise</key><value>0.25</value></param>
</block>
<block>
<key>blocks_peak_detector_xb</key>
<param><key>id</key><value>blocks_peak_detector_xb_0_0</value></param>
<param><key>alpha</key><value>0.001</value></param>
<param><key>type</key><value>float</value></param>
<param><key>look_ahead</key><value>10</value></param>
<param><key>threshold_factor_fall</key><value>0.40</value></param>
<param><key>threshold_factor_rise</key><value>0.25</value></param>
</block>
<block>
<key>blocks_sample_and_hold_xx</key>
<param><key>id</key><value>blocks_sample_and_hold_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_sample_and_hold_xx</key>
<param><key>id</key><value>blocks_sample_and_hold_xx_0_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>C:\Users\Yuan Wang\Desktop\fm_radio_qq\fm_demod_test_16bit.wav</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_0</value></param>
<param><key>cutoff_freq</key><value>15e3</value></param>
<param><key>type</key><value>interp_fir_filter_fff</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>samp_rate</key><value>384e3</value></param>
<param><key>width</key><value>2e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_0_0</value></param>
<param><key>cutoff_freq</key><value>15e3</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>384e3</value></param>
<param><key>width</key><value>2e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_0_0_0</value></param>
<param><key>cutoff_freq</key><value>15e3</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>384e3</value></param>
<param><key>width</key><value>2e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_0_1</value></param>
<param><key>cutoff_freq</key><value>15e3</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>384e3</value></param>
<param><key>width</key><value>2e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_1</value></param>
<param><key>cutoff_freq</key><value>80000</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>sample_rate</value></param>
<param><key>width</key><value>10000</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>notebook</key>
<param><key>id</key><value>nb</value></param>
<param><key>labels</key><value>['Frequency Control','Channel Spectrum','Key Demod Signals', 'Pilot Spectrum','Audio Signals']</value></param>
<param><key>style</key><value>wx.NB_TOP</value></param>
</block>
<block>
<key>pluto_source</key>
<param><key>id</key><value>pluto_source_0</value></param>
<param><key>bbdc</key><value>True</value></param>
<param><key>buffer_size</key><value>0x20000</value></param>
<param><key>uri</key><value>uri</value></param>
<param><key>auto_filter</key><value>True</value></param>
<param><key>filter</key><value></value></param>
<param><key>gain</key><value>"manual"</value></param>
<param><key>frequency</key><value>int(fm_freq)</value></param>
<param><key>manual_gain</key><value>74.0</value></param>
<param><key>quadrature</key><value>True</value></param>
<param><key>rfdc</key><value>True</value></param>
<param><key>bandwidth</key><value>20000000</value></param>
<param><key>samplerate</key><value>sample_rate</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>8</value></param>
<param><key>interp</key><value>3</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_0_0</value></param>
<param><key>decim</key><value>8</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_0_0_0</value></param>
<param><key>decim</key><value>8</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>uri</value></param>
<param><key>label</key><value>URI</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>ip:pluto.local</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>avg_alpha</key><value>0.2</value></param>
<param><key>average</key><value>True</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>notebook</key><value>nb,0</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>-10</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>samp_rate</key><value>sample_rate</value></param>
<param><key>title</key><value>SDR Sample Spectrum</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>window.hanning</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>5</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0_0_0_0</value></param>
<param><key>avg_alpha</key><value>0.2</value></param>
<param><key>average</key><value>True</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>notebook</key><value>nb, 3</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>samp_rate</key><value>384e3</value></param>
<param><key>title</key><value>Recovered 38 kHz Sub-carrier Spectrum</value></param>
<param><key>type</key><value>float</value></param>
<param><key>win</key><value>window.hamming</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0_0_0_0_0</value></param>
<param><key>avg_alpha</key><value>0.2</value></param>
<param><key>average</key><value>True</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>notebook</key><value>nb, 1</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>samp_rate</key><value>384e3</value></param>
<param><key>title</key><value>Channel Spectrum</value></param>
<param><key>type</key><value>float</value></param>
<param><key>win</key><value>window.hamming</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>notebook</key><value>nb, 2</value></param>
<param><key>num_inputs</key><value>4</value></param>
<param><key>samp_rate</key><value>384e3</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>title</key><value>Key Signal Scopes</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_AUTO</value></param>
<param><key>type</key><value>float</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0_0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>notebook</key><value>nb, 4</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>samp_rate</key><value>48e3</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>title</key><value>L/R Audio Channel</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_AUTO</value></param>
<param><key>type</key><value>float</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>dynamic_range</key><value>50</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>notebook</key><value>nb,0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>samp_rate</key><value>sample_rate</value></param>
<param><key>title</key><value>SDR Sample Waterfall</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
</block>
<connection><source_block_id>analog_fm_deemph_0</source_block_id><sink_block_id>rational_resampler_xxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_fm_deemph_1</source_block_id><sink_block_id>rational_resampler_xxx_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_fm_demod_cf_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_pll_refout_cc_0</source_block_id><sink_block_id>blocks_complex_to_real_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_pll_refout_cc_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_pll_refout_cc_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>band_pass_filter_0_0</source_block_id><sink_block_id>analog_pll_refout_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0_0</source_block_id><sink_block_id>blocks_complex_to_real_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0_0_0_0</source_block_id><sink_block_id>blocks_complex_to_real_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0_1</source_block_id><sink_block_id>analog_fm_deemph_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0_2</source_block_id><sink_block_id>analog_fm_deemph_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blks2_selector_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>blocks_peak_detector_xb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>wxgui_fftsink2_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0_0_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>band_pass_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_2</source_block_id><sink_block_id>blocks_peak_detector_xb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>band_pass_filter_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0</source_block_id><sink_block_id>low_pass_filter_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_peak_detector_xb_0</source_block_id><sink_block_id>blocks_sample_and_hold_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_peak_detector_xb_0_0</source_block_id><sink_block_id>blocks_sample_and_hold_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_sample_and_hold_xx_0</source_block_id><sink_block_id>low_pass_filter_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_sample_and_hold_xx_0_0</source_block_id><sink_block_id>low_pass_filter_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0</source_block_id><sink_block_id>blks2_selector_0_2</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>low_pass_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0</source_block_id><sink_block_id>blks2_selector_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0</source_block_id><sink_block_id>blks2_selector_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0_0</source_block_id><sink_block_id>blks2_selector_0_1</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0_0_0</source_block_id><sink_block_id>blks2_selector_0_2</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0_1</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0_1</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_1</source_block_id><sink_block_id>analog_fm_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pluto_source_0</source_block_id><sink_block_id>low_pass_filter_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pluto_source_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pluto_source_0</source_block_id><sink_block_id>wxgui_waterfallsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_sample_and_hold_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_sample_and_hold_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>low_pass_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>wxgui_fftsink2_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0_0</source_block_id><sink_block_id>audio_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0_0</source_block_id><sink_block_id>wxgui_scopesink2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0_0_0</source_block_id><sink_block_id>audio_sink_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0_0_0</source_block_id><sink_block_id>wxgui_scopesink2_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
